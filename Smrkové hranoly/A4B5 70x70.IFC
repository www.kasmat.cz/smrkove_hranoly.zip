Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: A4B5 70x70.IFC
Time: 2023-06-21T10:15:52
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: A4B5 70x70
In: Default Storey
PredefinedType: ELEMENT; Material: Smrk
